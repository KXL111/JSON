# Keil uVision project CommGateway.uvprojx, settings and files
target CommGateway (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: CommGateway +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,HSE_VALUE=8000000
  c include: ..\inc;..\..\..\STM32F4xx_Firmware_Library\CMSIS;..\..\..\STM32F4xx_Firmware_Library\Device;..\..\..\STM32F4xx_Firmware_Library\STM32F4xx_StdPeriph_Driver\inc;..\..\..\STM32F4xx_Firmware_Library\STM32F4x7_ETH_Driver\inc;..\..\..\Third_party\lwip-2.2.1\src\include;..\..\..\Third_party\lwip-2.2.1\port\STM32F4xx;..\..\..\Third_party\FreeRTOS-Kernel-11.2.0\include;..\..\..\Third_party\FreeRTOS-Kernel-11.2.0\portable\RVDS\ARM_CM4F
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\CommGateway.sct
  group App
    ../src/: main.c term_task.c bd_task.c tt_task.c dev_status.c
  group Protocol
    ../src/: bd_proto.c json.c gbk.c gbk_table.c
  group Driver
    ../src/: ethernetif.c net.c udp_link.c serial.c uuid.c wdg.c log.c
  group Config
    ../inc/: app_config.h msg_types.h FreeRTOSConfig.h lwipopts.h stm32f4x7_eth_conf.h
    ./: CommGateway.sct
  group STM32F4xx_StdPeriph
    ../../../STM32F4xx_Firmware_Library/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_rcc.c stm32f4xx_gpio.c stm32f4xx_usart.c stm32f4xx_dma.c stm32f4xx_syscfg.c stm32f4xx_iwdg.c stm32f4xx_rng.c stm32f4xx_dbgmcu.c
    ../../../STM32F4xx_Firmware_Library/STM32F4x7_ETH_Driver/src/: stm32f4x7_eth.c
  group CMSIS
    ../../../STM32F4xx_Firmware_Library/Device/: system_stm32f4xx.c
  group Startup
    ../../../STM32F4xx_Firmware_Library/Device/: startup_stm32f40_41xxx.s
  group lwIP
    ../../../Third_party/lwip-2.2.1/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../Third_party/lwip-2.2.1/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../../Third_party/lwip-2.2.1/src/core/ipv4/: acd.c autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../../Third_party/lwip-2.2.1/src/netif/: ethernet.c
    ../../../Third_party/lwip-2.2.1/port/STM32F4xx/FreeRTOS/: sys_arch.c
  group FreeRTOS
    ../../../Third_party/FreeRTOS-Kernel-11.2.0/: tasks.c queue.c list.c timers.c event_groups.c stream_buffer.c
    ../../../Third_party/FreeRTOS-Kernel-11.2.0/portable/RVDS/ARM_CM4F/: port.c
    ../../../Third_party/FreeRTOS-Kernel-11.2.0/portable/MemMang/: heap_4.c
  group Doc
    ../: readme.txt
